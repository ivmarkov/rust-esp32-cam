## sdkconfig.defaults
```kconfig
#CONFIG_ESP32_SPIRAM_SUPPORT=y
CONFIG_RTCIO_SUPPORT_RTC_GPIO_DESC=y
CONFIG_BOOTLOADER_LOG_LEVEL_ERROR=y
```
